# Keil uVision project StreetLightsControler.uvproj, settings and files
target StreetLightsControler (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: StreetLightsControler +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe  --bin -o   ..\OUTPUT\Obj\SLC.bin ..\OUTPUT\Obj\StreetLightsControler.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\DEVICEDRIVER;..\FREERTOS\inc;..\MEMORY;..\JSON;..\FWLIB\inc;..\PROTOCOL;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\PERIPHERAL\iic1;..\DEVICEDRIVER\24cxx;..\DEVICEDRIVER\sht2x;..\DEVICEDRIVER\bh1750;..\PERIPHERAL\iic2;..\DEVICEDRIVER\led;..\PERIPHERAL\rtc;..\PERIPHERAL\usart;..\DEVICEDRIVER\bcxx;..\PLATFORMS;..\DEVICEDRIVER\power;..\DEVICEDRIVER\att7059x;..\DEVICEDRIVER\cd4015b;..\DEVICEDRIVER\dali;..\PERIPHERAL\dac;..\DEVICEDRIVER\pwm;..\DEVICEDRIVER\ntc;..\DEVICEDRIVER\att7053a;..\PERIPHERAL\spi
  memory RVCT4: ROM 0x8006000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c common.c rtos_task.c task_led.c task_hci.c task_sensor.c task_net.c task_main.c stm32f10x_it.c event.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group PERIPHERAL
    ../PERIPHERAL/iic1/: iic1.c
    ../PERIPHERAL/rtc/: rtc.c
    ../PERIPHERAL/dac/: dac.c
    ../PERIPHERAL/usart/: uart4.c usart.c
    ../PERIPHERAL/spi/: spi.c
  group DEVICEDRIVER
    ../DEVICEDRIVER/24cxx/: 24cxx.c
    ../DEVICEDRIVER/led/: led.c
    ../DEVICEDRIVER/power/: inventr.c
    ../DEVICEDRIVER/pwm/: pwm.c
    ../DEVICEDRIVER/dali/: dali.c
    ../DEVICEDRIVER/cd4015b/: cd4051b.c
    ../DEVICEDRIVER/ntc/: ntc.c
    ../DEVICEDRIVER/bcxx/: bcxx.c at_cmd.c
    ../DEVICEDRIVER/att7053a/: att7053c.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group PROTOCOL
    ../PROTOCOL/: net_protocol.c
  group MEMORY
    ../MEMORY/: memb.c fifo.c malloc.c ringbuf.c
  group PLATFORMS
    ../PLATFORMS/: memory.c socket.c utils.c
  group FREERTOS
    ../FREERTOS/src/: croutine.c event_groups.c list.c port.c queue.c tasks.c timers.c
